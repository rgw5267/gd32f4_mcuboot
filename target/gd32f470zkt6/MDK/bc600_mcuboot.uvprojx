# Keil uVision project bc600_mcuboot.uvprojx, settings and files
target bc600_mcuboot (6160000::V6.16::ARMCLANG)
  device: GD32F470ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bc600_mcuboot
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,NDEBUG
  c include: ..\..\..\aft_bsp_gd32\gd32_drivers;..\..\..\aft_bsp_gd32\GD32F4xx_Firmware_Library\CMSIS;..\..\..\aft_bsp_gd32\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\..\..\aft_bsp_gd32\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\aft_sdk\src;..\..\..\aft_sdk\src\components\drivers;..\..\..\aft_sdk\src\3rdparty\fal\inc;..\..\..\aft_sdk\src\3rdparty\mcuboot\boot\bootutil\include;..\..\..\aft_sdk\src\3rdparty\mcuboot\boot\bootutil\src;..\..\..\app;..\board;..\board\fal_porting;..\board\mcuboot_porting\include;..\..\..\aft_sdk\src\3rdparty\SEGGER_RTT_V752d\RTT;..\..\..\aft_sdk\src\3rdparty\mcuboot\ext\mbedtls-asn1\include;..\..\..\aft_sdk\src\3rdparty\mcuboot\ext\mbedtls\include;..\..\..\aft_sdk\src\3rdparty\mcuboot\ext\fiat\src;..\..\..\aft_sdk\src\3rdparty\mcuboot\ext\tinycrypt-sha512\lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../../app/: app_main.c gd32f4xx_it.c
  group board
    ../board/: sdk_board.c
  group startup
    ../board/: startup_gd32f450_470.s system_gd32f4xx.c
  group sdk/drivers
    ../../../aft_sdk/src/components/drivers/: sdk_common.c sdk_uart.c sdk_soft_timer.c
  group sdk/gd32
    ../../../aft_bsp_gd32/gd32_drivers/: gd32_common.c gd32_flash_f4xx.c
  group sdk
    ../../../aft_sdk/src/: sdk_log.c sdk_utils.c sdk_os_port_none.c
  group sdk/fal
    ../../../aft_sdk/src/3rdparty/fal/src/: fal.c fal_flash.c fal_partition.c
    ../board/fal_porting/: fal_flash_w25qxx_port.c fal_cfg.h fal_flash_sdk_flash.c
  group sdk/mcuboot
    ../../../aft_sdk/src/3rdparty/mcuboot/boot/bootutil/src/: loader.c fault_injection_hardening.c swap_scratch.c bootutil_misc.c bootutil_public.c image_validate.c tlv.c image_ed25519.c swap_move.c swap_misc.c
    ../board/mcuboot_porting/include/flash_map_backend/: flash_map_backend.h
    ../board/mcuboot_porting/include/mcuboot_config/: mcuboot_assert.h mcuboot_config.h mcuboot_logging.h
    ../board/mcuboot_porting/include/os/: os_malloc.h
    ../board/mcuboot_porting/include/sysflash/: sysflash.h
    ../board/mcuboot_porting/include/watchdog/: watchdog.h
    ../board/mcuboot_porting/src/flash_map_backend/: flash_map_backend.c
    ../board/mcuboot_porting/src/keys/: app_enc_keys.c
  group sdk/console
    ../../../aft_sdk/src/3rdparty/SEGGER_RTT_V752d/RTT/: SEGGER_RTT.c
  group library
    ../../../aft_bsp_gd32/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_fmc.c
  group mcuboot/ext
    ../../../aft_sdk/src/3rdparty/mcuboot/ext/mbedtls-asn1/src/: asn1parse.c platform_util.c
    ../../../aft_sdk/src/3rdparty/mcuboot/ext/fiat/src/: curve25519.c
    ../../../aft_sdk/src/3rdparty/mcuboot/ext/mbedtls/library/: sha256.c bignum.c sha512.c
software components: CMSIS:CORE 5.6.0
